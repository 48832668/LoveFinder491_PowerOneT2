# Keil uVision project LoveFinder491_PowerOneT2.uvprojx, settings and files
target LoveFinder491_PowerOneT2 (6240000::V6.24::ARMCLANG)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: LoveFinder491_PowerOneT2 +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32G030xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../LoveFinderLib/ST7735;../LoveFinderLib/SW3526;../LoveFinderLib/UART;../LoveFinderLib/NTC_ADC
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g030xx.s
  group Application/User/Core
    ../Core/Src/: main.cpp gpio.c adc.c dma.c i2c.c spi.c tim.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group LoveFinderLib
    ../LoveFinderLib/SW3526/: SW3526.cpp
    ../LoveFinderLib/ST7735/: ST7735.cpp fonts.cpp
    ../LoveFinderLib/NTC_ADC/: NTC_ADC.cpp
software components: CMSIS:CORE 6.1.1
